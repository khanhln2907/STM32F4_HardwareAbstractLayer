# Keil uVision project STM32F4_HardwareAbstractLayer.uvprojx, settings and files
target STM32F4_HAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_HardwareAbstractLayer
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Library Header
    ./Library/: HAL_GPIO.h
  group Library Source
    ./Library/: HAL_GPIO.c
  group Header
    ./UnitTests/: main.h
  group Source
    ./UnitTests/: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
